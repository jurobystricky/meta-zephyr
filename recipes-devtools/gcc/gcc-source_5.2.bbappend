FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0042-arm-thumb2-multilib.patch"

